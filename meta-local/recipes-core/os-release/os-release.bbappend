VERSION = "0.0.1"
DISTRO_NAME = "rpi"
OS_RELEASE_FIELDS = "PRETTY_NAME NAME VERSION"
