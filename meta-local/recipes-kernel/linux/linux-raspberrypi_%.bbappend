FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += " \
    file://01_misc.cfg \
    file://02_route.cfg \
    file://03_docker.cfg \
"
